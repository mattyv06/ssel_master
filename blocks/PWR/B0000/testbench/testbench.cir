.title KiCad schematic
.include "sub/diode/pmeg4005ct.sub"
.include "sub/sim/beh_iload.sub"
.include "sub/transistor/si4904.sub"
Vstring1 /DUAL_PWR_PATH/VINA 0 dc 10
Vstring2 /DUAL_PWR_PATH/VINB 0 dc 9
Iload1 0 /L1 dc 10m
V~ctl1 /DUAL_PWR_PATH/~CTLA 0 pwl(0 0 0.1 0 0.1001 12 1 12 1.0001 0 2 0 2.0001 12)
Vctl1 /DUAL_PWR_PATH/CTLA 0 pwl(0 0 1 0 1.0001 12 2 12 2.0001 0)
V~ctl2 /DUAL_PWR_PATH/~CTLB 0 pwl(0 0 0.1 0 0.1001 12 2 12 2.0001 0 3 0 3.0001 12)
Vctl2 /DUAL_PWR_PATH/CTLB 0 pwl(0 0 2 0 2.0001 12 3 12 3.0001 0)
Iload2 0 /L2 pulse(0 100m 1 0.5 0.5 0 1 2)
Vpump1 /DUAL_PWR_PATH/VBIAS 0 dc 12
XB1 /DUAL_PWR_PATH/VSCHOTTKY /L1 beh_iload
XB2 /DUAL_PWR_PATH/VIDEAL /L2 beh_iload
XQ1 /DUAL_PWR_PATH/SA /DUAL_PWR_PATH/GA /DUAL_PWR_PATH/~SA /DUAL_PWR_PATH/~GA /DUAL_PWR_PATH/VINA /DUAL_PWR_PATH/VINA /DUAL_PWR_PATH/VINA /DUAL_PWR_PATH/VINA SI4904
XQ3 /DUAL_PWR_PATH/SB /DUAL_PWR_PATH/GB /DUAL_PWR_PATH/~SB /DUAL_PWR_PATH/~GB /DUAL_PWR_PATH/VINB /DUAL_PWR_PATH/VINB /DUAL_PWR_PATH/VINB /DUAL_PWR_PATH/VINB SI4904
XQ2 /DUAL_PWR_PATH/SA /DUAL_PWR_PATH/GA /DUAL_PWR_PATH/SB /DUAL_PWR_PATH/GB /DUAL_PWR_PATH/VIDEAL /DUAL_PWR_PATH/VIDEAL /DUAL_PWR_PATH/VIDEAL /DUAL_PWR_PATH/VIDEAL SI4904
XD1 /DUAL_PWR_PATH/~SA /DUAL_PWR_PATH/~SB /DUAL_PWR_PATH/VSCHOTTKY PMEG4005CT
RR1 /DUAL_PWR_PATH/CTLA /DUAL_PWR_PATH/GA 1k
RR8 /DUAL_PWR_PATH/~CTLB /DUAL_PWR_PATH/~GB 1k
RR2 /DUAL_PWR_PATH/~CTLA /DUAL_PWR_PATH/~GA 1k
RR7 /DUAL_PWR_PATH/CTLB /DUAL_PWR_PATH/GB 1k
RR5 /DUAL_PWR_PATH/GB /DUAL_PWR_PATH/VBIAS 10k
RR3 /DUAL_PWR_PATH/VBIAS /DUAL_PWR_PATH/GA 10k
RR6 /DUAL_PWR_PATH/~GB /DUAL_PWR_PATH/VBIAS 10k
RR4 /DUAL_PWR_PATH/VBIAS /DUAL_PWR_PATH/~GA 10k
.tran 4
.end
